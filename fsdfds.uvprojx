# Keil uVision project fsdfds.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fsdfds +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 wLevel=4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APPLICATION
    ./: main.c
  group MCAL
    ./: Dio.c GPT.c NVIC.c SysTick_Timer.c
  group SERVICE
    ./: std_Types.h Bit_Math.h
  group LIBRARIES
    ./: Dio_Types.h Dio_Interface.h Timers_Reg.h GPT_Types.h GPT_Interface.h NVIC_Interface.h Dio_Private.h SysTick_Timer_Interface.h SysTick_Timer_Cfg.h SysTick_Timer_Private.h NVIC_Types.h NVIC_Reg.h SysTick_Timer_Reg.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
